# Keil uVision project led_output_cm4.uvprojx, settings and files
target led_output_cm4 Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_output_cm4.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54114J256BD64_cm4
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: CMSIS;board;doc;drivers;source;startup;utilities
  asm define: CPU_LPC54114J256_M4, DEBUG, __CC_ARM, KEIL,NO_CRP
  asm include: CMSIS;board;doc;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: drivers/keil_lib_power.lib
keil_lib_power.lib
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h LPC54114_cm4.h LPC54114_cm4_features.h system_LPC54114_cm4.c system_LPC54114_cm4.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group source
    source/: gpio_led_output.c
  group startup
    startup/: startup_LPC54114_cm4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
target led_output_cm4 Release (ARM-ADS)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: led_output_cm4.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54114J256BD64_cm4
  c misc: as above
  c include: CMSIS;board;doc;drivers;source;startup;utilities
  asm define: CPU_LPC54114J256_M4, NDEBUG, __CC_ARM, KEIL
  asm include: CMSIS;board;doc;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: drivers/keil_lib_power.lib
keil_lib_power.lib
--remove
